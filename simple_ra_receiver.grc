<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simple_ra_receiver</value></param>
<param><key>author</key><value>Marcus D. Leech (patchvonbraun), Science Radio Laboratories</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>A very simple RA total-power and spectral receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Multimode RA Receiver.  Rev: @@REV@@</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>aper</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>aperture</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Effective Aperture (meters)</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>cal_enable</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
<param><key>label</key><value>Cal ON</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_man_res</value></param>
<param><key>value</key><value>sra.calib_onoff_manual (cal_enable,cdevn,cdevrate,cdevon,cdevoff,"\r")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_result</value></param>
<param><key>value</key><value>sra.calib_onoff_auto(tod_value, cdevn, cdevrate, cdevinit, cdevoff, cdevoff, "\r", cinterval, contime)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cal_sig4log</value></param>
<param><key>value</key><value>1 if (cr == "ON" or cal_enable == True ) else 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cex</value></param>
<param><key>value</key><value>True if cal_result != None else False</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>clear_not</value></param>
<param><key>choices</key><value>["Clear"]</value></param>
<param><key>value</key><value>"Clear"</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Clear Notches</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>clipping_probe_out</value></param>
<param><key>block_id</key><value>clipping_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>correct_fftrate</value></param>
<param><key>value</key><value>int(samp_rate/correct_fftsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>correct_fftsize</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>correction_file</value></param>
<param><key>value</key><value>cfile if en_cfile == True else "/dev/notachancebuddy"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cr</value></param>
<param><key>value</key><value>cal_result if cex == True else "OFF"</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>dc_gain</value></param>
<param><key>choices</key><value>[100, 1000, 10000, 100000]</value></param>
<param><key>value</key><value>int(dcg)</value></param>
<param><key>grid_pos</key><value>2,3,1,1</value></param>
<param><key>label</key><value>DC Gain</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dedisp_filt</value></param>
<param><key>value</key><value>sra.compute_dispfilter (dm,1.0,samp_rate,freq+sky_off)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>delayA</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Delay A</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>delayB</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>4,2,1,1</value></param>
<param><key>label</key><value>Delay B</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>det_bw</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>dbw</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Detector Bandwidth</value></param>
<param><key>max</key><value>samp_rate/1.10</value></param>
<param><key>min</key><value>samp_rate/15</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>det_lpf</value></param>
<param><key>value</key><value>[1.0] if dfd == 1 else firdes.low_pass(1.0,israte,det_bw/2.10,det_bw/3.0,firdes.WIN_HAMMING,6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>det_rate</value></param>
<param><key>value</key><value>int(20.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dfilt1</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,samp_rate,samp_rate/6.0,samp_rate/4.25)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dfilt2</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,samp_rate/5,predet_rate/2.25,predet_rate/6.0)</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>dm</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1500.0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Dispersion Measure</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>en_cfile</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Apply Correction File</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>en_correct</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Correct Spectrum</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>en_notches</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,6,1,1</value></param>
<param><key>label</key><value>Ena Notch Filt</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ephemerides</value></param>
<param><key>value</key><value>sra.fringe_stop (fspacer, ira, idecln, longitude, latitude, ibaseline, fstop, phase, freq+skoffs)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>est_dyn_file</value></param>
<param><key>value</key><value>sra.get_correct_fn(pacer)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ev</value></param>
<param><key>value</key><value>sra.exit_cleanly(exit_now)</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>exit_now</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>7,2,1,1</value></param>
<param><key>label</key><value>EXIT CLEANLY</value></param>
<param><key>labels</key><value>["EXIT","EXIT"]</value></param>
<param><key>notebook</key><value>Main,3</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_probe_out</value></param>
<param><key>block_id</key><value>fft_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0]*correct_fftsize</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftrate</value></param>
<param><key>value</key><value>int(samp_rate/fftsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>file_rate</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>foo</value></param>
<param><key>value</key><value>sra.clear_notches(clear_not)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>foo2</value></param>
<param><key>value</key><value>sra.defnotch(notch,israte,freq)</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>fratio</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>5</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Folding Ratio</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>frequency</value></param>
<param><key>formatter</key><value>sra.sra_formatter</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Tuner Frequency (Hz)</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fspacer</value></param>
<param><key>block_id</key><value>tp_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>fstop</value></param>
<param><key>value</key><value>True if fse == 1 else False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>4,3,1,1</value></param>
<param><key>label</key><value>Auto Fringe Rotation</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>rfgain</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>RF Gain (dB)</value></param>
<param><key>max</key><value>maxg</value></param>
<param><key>min</key><value>0</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hha</value></param>
<param><key>value</key><value>(ephemerides[1]/360.0)*24.0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ibaseline</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>baseline</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Baseline length (meters)</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>idecln</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>decln</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Declination</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>integ</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>tpint</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Integration Time (Seconds)</value></param>
<param><key>max</key><value>60</value></param>
<param><key>min</key><value>1</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>ira</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>ra</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
<param><key>label</key><value>Right Ascension</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>israte</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_disp</value></param>
<param><key>value</key><value>len(dedisp_filt)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>logger_det_a</value></param>
<param><key>block_id</key><value>det_probe_a</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>logger_det_b</value></param>
<param><key>block_id</key><value>det_probe_b</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>logger_psr</value></param>
<param><key>block_id</key><value>pulsar_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0]*pvec_size</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>logger_spec</value></param>
<param><key>block_id</key><value>fft_log_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0]*fftsize</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>logger_tp</value></param>
<param><key>block_id</key><value>tp_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>complex(0,0)</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nestimates</value></param>
<param><key>value</key><value>sra.get_num_estimates(pacer)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>notch</value></param>
<param><key>value</key><value>-1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>notch_taps</value></param>
<param><key>value</key><value>sra.getnotches(pacer)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pacer</value></param>
<param><key>block_id</key><value>tp_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfilt1</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,samp_rate,100e3,100e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfilt2</value></param>
<param><key>value</key><value>firdes.low_pass(1.0,samp_rate/10,10e3,3e3)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>phase</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>label</key><value>Correlation Phase Adjust (Deg)</value></param>
<param><key>max</key><value>180</value></param>
<param><key>min</key><value>-180</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>360</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pr</value></param>
<param><key>value</key><value>ephemerides[0]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>predet_rate</value></param>
<param><key>value</key><value>int(50e3)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psr_log_status</value></param>
<param><key>value</key><value>sra.log_psr_data (logger_psr, freq, idecln, srate, pulse_rate, dm, longitude, prefix, lrate,pulsar_enable,ira)</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>pulsar_enable</value></param>
<param><key>value</key><value>True if ppe &gt; 0 else False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,4,1,1</value></param>
<param><key>label</key><value>Enable Pulsar Processing</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>pulse_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0.7477</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Pulse Rate</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pvec_size</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ref_is_real</value></param>
<param><key>value</key><value>sra.intuit_mode(devid,devid2,devstr)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>ref_scale</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>refm</value></param>
<param><key>grid_pos</key><value>5,1,1,1</value></param>
<param><key>label</key><value>Ref chan scale</value></param>
<param><key>max</key><value>15.0</value></param>
<param><key>min</key><value>1.0/15.0</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>relative</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Relative Freq. Display</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(israte)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>scope_rate</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>sky_off</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>skoffs</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Sky F. Offset</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>spavg</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>spa</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Spectral Averaging (Minutes)</value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>0.25</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_steps</key><value>60</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spec_log_status</value></param>
<param><key>value</key><value>sra.log_fft_data (logger_spec, freq+sky_off, idecln, srate, longitude, prefix, lrate,splog_ena,ira,stype)</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>splog_ena</value></param>
<param><key>value</key><value>True if sple &gt; 0 else False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>1,4,1,1</value></param>
<param><key>label</key><value>Enable Spectral Logging</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tod_value</value></param>
<param><key>block_id</key><value>tp_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tor</value></param>
<param><key>value</key><value>3.1415926/180.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tp_log_status</value></param>
<param><key>value</key><value>sra.log_tp_data(sra.getreal(logger_tp), sra.getimag(logger_tp), freq+sky_off, idecln, dbw, longitude, prefix, lrate,ira,tplog_ena,expname,cal_sig4log,stype,logger_det_a*dc_gain,logger_det_b*dc_gain)</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>tplog_ena</value></param>
<param><key>value</key><value>True if tpld == 0 else False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>label</key><value>T.P. Logging Enabled</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tpmode</value></param>
<param><key>value</key><value>"Total Power" if ref_is_real == 0 else "Differential"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tpmodestr</value></param>
<param><key>value</key><value>"Total Power" if ref_is_real == 0 else "Differential Power"</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>israte</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Samp rate</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % ira</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Current RA</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>devid[0:7] if devstr == "NONE" else devstr[0:7]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,2,1,1</value></param>
<param><key>label</key><value>Device</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"YES" if clipping_probe_out &gt; 0.89 else "NO"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Clipping</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.3f" % math.sqrt(clipping_probe_out)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,1,1,1</value></param>
<param><key>label</key><value>Signal magnitude</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0_0_0_1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>len_disp</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,5,1,1</value></param>
<param><key>label</key><value>Dedisp Filter Length</value></param>
<param><key>notebook</key><value>Main,2</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0_0_0_1_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"ON" if sppe == 1 else "OFF"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,3</value></param>
<param><key>label</key><value>Adv. Spectral Features</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0_0_0_1_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"ENABLED" if spde == 1 else "DISABLED"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,5,1,3</value></param>
<param><key>label</key><value>Spectral Display</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_0_0_0_1_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Interferometer" if interf == 1 else tpmode</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,3,1,1</value></param>
<param><key>label</key><value>Obs. Mode</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_1</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % idecln</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Current DEC</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_1_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % latitude</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Current Latitude</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0_1_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % longitude</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Current Longitude</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>sra.cur_utc(tod_value)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Current UTC</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>sra.cur_sidereal(longitude,tod_value)[0]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,3,1,1</value></param>
<param><key>label</key><value>Current LMST</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>sra.cur_sidereal(longitude,tod_value)[0]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,7,1,1</value></param>
<param><key>label</key><value>Current LMST</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>sra.cur_sidereal(longitude,tod_value)[0]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Current LMST</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % ephemerides[1]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>label</key><value>Rel. HA (Deg)</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % hha</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,2,1,1</value></param>
<param><key>label</key><value>Rel. HA (Hours)</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%15.12f,%15.12f" % (ephemerides[0].real, ephemerides[0].imag)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Current Phase Correction</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0_0_0_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"MANUAL" if fstop == False else "AUTO"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Fringe Rotation Mode</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0_0_1</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"%5.2f" % sra.beamwidth(aper,freq+skoffs)</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,1,1,1</value></param>
<param><key>label</key><value>Beamwidth (Deg)</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_1_0_0_0_0_1_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"YES" if abs(ephemerides[1]) &lt; (sra.beamwidth(aper,freq+skoffs)/1.5) else "NO"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,2,1,1</value></param>
<param><key>label</key><value>In Beam</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_2</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Yes" if nestimates &gt;= 30 else "No"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Correction Estimate Valid</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_2_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>est_dyn_file</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,4</value></param>
<param><key>label</key><value>Curr. Corr. File</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_3</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>cal_result</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,2,1,1</value></param>
<param><key>label</key><value>ACAL</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_3_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>skoffs+freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
<param><key>label</key><value>Sky Freq</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_4</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Like this software? PayPal to: sales@science-radio-labs.com"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>11,0,1,3</value></param>
<param><key>label</key><value>Info</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_4_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"Marcus D. Leech.  mleech@ripnet.com or sales@science-radio-labs.com"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>9,0,1,3</value></param>
<param><key>label</key><value>Author</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_4_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>"ABOVE EPHEMERIS DATA ASSUMES MERIDIAN-TRANSIT WITH STRICT E-W BASELINE"</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5,0,1,4</value></param>
<param><key>label</key><value>NOTE</value></param>
<param><key>notebook</key><value>Main,3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>x</value></param>
<param><key>value</key><value>sra.set_fftsize(fftsize)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>x2</value></param>
<param><key>value</key><value>sra.update_correction(fft_probe_out)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>x3</value></param>
<param><key>value</key><value>sra.newfreq (freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xdm</value></param>
<param><key>value</key><value>dm if pulsar_enable == True else 1.0</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>labels</key><value>['Continuum + Controls', 'Spectral','Pulsar', 'Ephemeris']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ant</value></param>
<param><key>label</key><value>Antenna selector</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>Default</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>aperture</value></param>
<param><key>label</key><value>Effective Aperture</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baseline</value></param>
<param><key>label</key><value>Interferometer Baseline (meters)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>sppe</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>sppe</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1</value></param>
<param><key>input_index</key><value>interf</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>ref_is_real</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_2</value></param>
<param><key>input_index</key><value>sppe</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_1_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delayA</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>delayB</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>1 if pulsar_enable == True else 100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_1</value></param>
<param><key>n</key><value>5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_2</value></param>
<param><key>n</key><value>int(predet_rate/det_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_3</value></param>
<param><key>n</key><value>int(det_rate/file_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_4</value></param>
<param><key>n</key><value>fftrate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_4_0</value></param>
<param><key>n</key><value>correct_fftrate/5</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>correct_fftsize</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_5</value></param>
<param><key>n</key><value>1 if sppe == 1 else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_5_0</value></param>
<param><key>n</key><value>1 if sppe == 1 else 1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_6</value></param>
<param><key>n</key><value>1 if spde == 1 else 100</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_7</value></param>
<param><key>n</key><value>int(det_rate/scope_rate)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>dc_gain</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>ref_scale</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>pr</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>pvec_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdevinit</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"C,0,0,0,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdevn</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/dev/ttyACM0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdevoff</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"PO,B,0,0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdevon</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"PO,B,0,1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cdevrate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>19200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cfile</value></param>
<param><key>label</key><value>Spectral Correction file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/dev/never_will_open</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cinterval</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3600</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>clipping_probe</value></param>
<param><key>alpha</key><value>1.0/(samp_rate*2.0)</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>clock</value></param>
<param><key>label</key><value>Clock rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>100.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>contime</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>90</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dbw</value></param>
<param><key>label</key><value>Detector Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dcg</value></param>
<param><key>label</key><value>DC (post-detector) gain</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decln</value></param>
<param><key>label</key><value>Declination</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-28.0</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>det_probe_a</value></param>
<param><key>alpha</key><value>1.0/(samp_rate*2)</value></param>
<param><key>threshold</key><value>-100</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>det_probe_b</value></param>
<param><key>alpha</key><value>1.0/(samp_rate*2)</value></param>
<param><key>threshold</key><value>-100</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid</value></param>
<param><key>label</key><value>USRP Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>addr=192.168.10.2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid2</value></param>
<param><key>label</key><value>2nd Devid ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>file=/dev/zero,rate=10.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devstr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>NONE</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dfd</value></param>
<param><key>label</key><value>Detector Filter Disable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>expname</value></param>
<param><key>label</key><value>Experiment Name</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"SRA"</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>sra.compute_correction(en_correct,correction_file)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[complex(1.0,0.0)] if en_notches == False else notch_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_2</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>det_lpf</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_2_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>det_lpf</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>dedisp_filt</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_4</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value>dfilt1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_4_0</value></param>
<param><key>decim</key><value>int((samp_rate/5)/predet_rate)</value></param>
<param><key>taps</key><value>dfilt1</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_5</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>pfilt1</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_5_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>pfilt2</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_log_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>fft_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>correct_fftsize</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>8192</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fifo</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/dev/null"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frequency</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>15.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fse</value></param>
<param><key>label</key><value>Fringe Stop Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import simple_ra_utils as sra</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from gnuradio.filter import firdes</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interf</value></param>
<param><key>label</key><value>Interferometer Mode</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>latitude</value></param>
<param><key>label</key><value>Local Latitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>44.9</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>1.0/float(1*15*fftrate)</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>correct_fftsize</value></param>
<param><key>frame_rate</key><value>fftrate/2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0_0</value></param>
<param><key>avg_alpha</key><value>1.0/float(spavg*15*fftrate)</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>frame_rate</key><value>fftrate if sple else fftrate/20</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>Local Longitude</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-76.02</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lrate</value></param>
<param><key>label</key><value>Log rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>maxg</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>VARIABLES</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>COMMAND LINE PARAMS</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>Geo/Astro Coords</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0</value></param>
<param><key>note</key><value>Fixed hardware params</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_0</value></param>
<param><key>note</key><value>CAL hardware params</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_1</value></param>
<param><key>note</key><value>Sig. proc. params</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_1_0</value></param>
<param><key>note</key><value>Filenames</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_1_0_0</value></param>
<param><key>note</key><value>Misc config</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0_0_1_0_1</value></param>
<param><key>note</key><value>Optional proc. ena/dis</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>1-Lag Cross Correlate</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>Phase Rotation </value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>E/W delays</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0</value></param>
<param><key>note</key><value>A: detector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0</value></param>
<param><key>note</key><value>A-B difference</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_0</value></param>
<param><key>note</key><value>A: bandwidth shaper</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_1_0</value></param>
<param><key>note</key><value>Contin./Corr. select</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_1_0_0</value></param>
<param><key>note</key><value>POST DET PROCESSING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_1_0_0_0</value></param>
<param><key>note</key><value>Power logging</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_1_0_0_1</value></param>
<param><key>note</key><value>Roughing filters</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_0_1_0_0_1_0</value></param>
<param><key>note</key><value>Final integrator</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1</value></param>
<param><key>note</key><value>B: detector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0</value></param>
<param><key>note</key><value>B: bandwidth shaper</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0</value></param>
<param><key>note</key><value>Basic/Adv. select</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_0</value></param>
<param><key>note</key><value>Specest for flattening</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_0_0</value></param>
<param><key>note</key><value>Sky/Ref select</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1</value></param>
<param><key>note</key><value>Spec. Correct</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0</value></param>
<param><key>note</key><value>Notches</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_0</value></param>
<param><key>note</key><value>Dedispersion</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_0_0</value></param>
<param><key>note</key><value>Level indicator</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_1</value></param>
<param><key>note</key><value>Spectral Logging</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_1_0</value></param>
<param><key>note</key><value>Basic/Adv. select</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_1_1</value></param>
<param><key>note</key><value>Pulsar processing</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_1_1_0</value></param>
<param><key>note</key><value>Pulsar detector</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_1_1_0_0</value></param>
<param><key>note</key><value>Two stage filtering</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_0_1_0_1_1_1</value></param>
<param><key>note</key><value>Pulsar logging</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_0_1</value></param>
<param><key>note</key><value>!!NO ADV FILT ON B!!!</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2_0_1_1</value></param>
<param><key>note</key><value>Ref mult.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>note</key><value>Function Probes</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>"" if ant == "Default" else ant</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>israte*0.8</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value>"" if ant == "Default" else ant</value></param>
<param><key>bb_gain1</key><value>20</value></param>
<param><key>bw1</key><value>israte*0.8</value></param>
<param><key>dc_offset_mode1</key><value>2</value></param>
<param><key>corr1</key><value>0</value></param>
<param><key>freq1</key><value>freq</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>if_gain1</key><value>20</value></param>
<param><key>iq_balance_mode1</key><value>1</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>args</key><value>devid+" "+devid2 if devstr == "NONE" else devstr</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>israte</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppe</value></param>
<param><key>label</key><value>Pulsar Processing Enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ppm</value></param>
<param><key>label</key><value>ppm error</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>Logfile prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>pulsar_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>pvec_size</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ra</value></param>
<param><key>label</key><value>Right Ascension</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>12.0</value></param>
</block>
<block>
<key>ra_synch_folder2</key>
<param><key>id</key><value>ra_synch_folder2_0</value></param>
<param><key>folding</key><value>fratio</value></param>
<param><key>samp_rate</key><value>int(samp_rate/(10*10*5))</value></param>
<param><key>vecsize</key><value>pvec_size</value></param>
<param><key>pulse_rate</key><value>pulse_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>refm</value></param>
<param><key>label</key><value>Reference Multiplier</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfgain</value></param>
<param><key>label</key><value>Gain of RF Front-End</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rpcport</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1420</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/10.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1</value></param>
<param><key>alpha</key><value>1.0/((predet_rate*integ)/1.75)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>skoffs</value></param>
<param><key>label</key><value>Sky Frequency Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spa</value></param>
<param><key>label</key><value>Spectral Averaging Constant</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spde</value></param>
<param><key>label</key><value>Spectral Display Enabled</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sple</value></param>
<param><key>label</key><value>Spectral logging enable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sppe</value></param>
<param><key>label</key><value>Spectral Processing enabled</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stype</value></param>
<param><key>label</key><value>File Save Type</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"both"</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>tp_probe</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tpint</value></param>
<param><key>label</key><value>Integration Time</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tpld</value></param>
<param><key>label</key><value>T.P. Logging Disable</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>vector_normalize</key>
<param><key>id</key><value>vector_normalize_0</value></param>
<param><key>vecsize</key><value>1024</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>S1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1</value></param>
<param><key>stream_id</key><value>DetA</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>FFTDisp</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>ADVFilts</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>FiltBB_A</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_0</value></param>
<param><key>stream_id</key><value>DetB</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_1</value></param>
<param><key>stream_id</key><value>PDFiltBB_B</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_1_0</value></param>
<param><key>stream_id</key><value>PDFiltBB_A</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_1_1</value></param>
<param><key>stream_id</key><value>Difference</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3_2</value></param>
<param><key>stream_id</key><value>Correlation</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>S1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>S1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>FiltBB_A</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0</value></param>
<param><key>stream_id</key><value>PDFiltBB_B</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>PDFiltBB_A</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>PDFiltBB_A</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_1</value></param>
<param><key>stream_id</key><value>DetB</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_1_0</value></param>
<param><key>stream_id</key><value>DetA</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_1_0_0</value></param>
<param><key>stream_id</key><value>Difference</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0_0</value></param>
<param><key>stream_id</key><value>ADVFilts</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0_0_0</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_3</value></param>
<param><key>stream_id</key><value>Correlation</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>S0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>FFTDisp</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>PDFiltBB_A</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3_0</value></param>
<param><key>stream_id</key><value>PDFiltBB_B</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.1</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0.0 if relative == True else (freq+sky_off)</value></param>
<param><key>fft_size</key><value>2048 if spde == 1 else 1024</value></param>
<param><key>freqvar</key><value>notch</value></param>
<param><key>notebook</key><value>Main,1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>8 if spde == 1 else 1</value></param>
<param><key>samp_rate</key><value>israte if spde == 1 else israte/100</value></param>
<param><key>title</key><value>Spectrum</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win_size</key><value>750,300</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>Main,0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>scope_rate</value></param>
<param><key>t_scale</key><value>450</value></param>
<param><key>title</key><value>tpmodestr if interf == 0 else "Cross Power"</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_STRIPCHART</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>win_size</key><value>550,250</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Power Level</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>Main,2</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>pulse_rate*pvec_size</value></param>
<param><key>t_scale</key><value>0.3</value></param>
<param><key>title</key><value>Pulsar Folded Pulses</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_FREE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>rpcport</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_6</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>fft_filter_xxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>blocks_keep_one_in_n_5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_2</source_block_id><sink_block_id>logpwrfft_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>fft_filter_xxx_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1</source_block_id><sink_block_id>virtual_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>fft_filter_xxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_1</source_block_id><sink_block_id>ra_synch_folder2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_3</source_block_id><sink_block_id>tp_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_4</source_block_id><sink_block_id>fft_log_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_4_0</source_block_id><sink_block_id>fft_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_5</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_5_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_6</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_7</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>virtual_sink_3_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_7</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>virtual_sink_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>virtual_sink_3_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_1</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2</source_block_id><sink_block_id>virtual_sink_3_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2_0</source_block_id><sink_block_id>virtual_sink_3_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_3</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_4</source_block_id><sink_block_id>fft_filter_xxx_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_4_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_5</source_block_id><sink_block_id>fft_filter_xxx_5_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_5_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_keep_one_in_n_4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ra_synch_folder2_0</source_block_id><sink_block_id>vector_normalize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1</source_block_id><sink_block_id>blocks_keep_one_in_n_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vector_normalize_0</source_block_id><sink_block_id>blocks_vector_to_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>vector_normalize_0</source_block_id><sink_block_id>pulsar_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>clipping_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>fft_filter_xxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>fft_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_1_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_1_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_1_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>blks2_selector_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>blocks_keep_one_in_n_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0_0_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_3</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>det_probe_a</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3_0</source_block_id><sink_block_id>det_probe_b</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
